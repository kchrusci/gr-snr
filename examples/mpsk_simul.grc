<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>mpsk_simul</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>arity</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>eq_gain</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>gui_hint</key><value>4,0,1,1</value></param>
<param><key>label</key><value>Equalizer: rate</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>0.1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>label</key><value>Channel: Frequency Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-0.1</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>0.1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_volt</value></param>
<param><key>value</key><value>0.001</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>Channel: Noise Voltage</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_bw</value></param>
<param><key>value</key><value>6.28/100.0</value></param>
<param><key>gui_hint</key><value>4,1,1,1</value></param>
<param><key>label</key><value>Phase: Bandwidth</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1.0</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>[1.0 + 0.0j, ]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>time_offset</value></param>
<param><key>value</key><value>1.00</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label</key><value>Channel: Timing Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.999</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>1.001</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>timing_loop_bw</value></param>
<param><key>value</key><value>6.28/100.0</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label</key><value>Time: BW</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>0.2</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>256</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>10000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1+1j</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_cma_equalizer_cc</key>
<param><key>id</key><value>digital_cma_equalizer_cc_0</value></param>
<param><key>mu</key><value>eq_gain</value></param>
<param><key>modulus</key><value>1</value></param>
<param><key>num_taps</key><value>15</value></param>
<param><key>sps</key><value>2</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>phase_bw</value></param>
<param><key>order</key><value>arity</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>timing_loop_bw</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>2</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>digital_psk_mod</key>
<param><key>id</key><value>digital_psk_mod_0</value></param>
<param><key>differential</key><value>True</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>constellation_points</key><value>arity</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_math</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>4000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.01</value></param>
</block>
<block>
<key>snr_channel_model_snr</key>
<param><key>id</key><value>snr_channel_model_snr_0</value></param>
<param><key>block_tags</key><value>False</value></param>
<param><key>epsilon</key><value>time_offset</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>noise_voltage</key><value>noise_volt</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>taps</value></param>
</block>
<block>
<key>snr_mpsk_receiver_snr_est_cc</key>
<param><key>id</key><value>snr_mpsk_receiver_snr_est_cc_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>tag_nsamples</key><value>10000</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_psk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>snr_channel_model_snr_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_cma_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_psk_mod_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>snr_channel_model_snr_0</source_block_id><sink_block_id>snr_mpsk_receiver_snr_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>snr_channel_model_snr_0</source_block_id><sink_block_id>snr_mpsk_receiver_snr_est_cc_0</sink_block_id><source_key>snr_level_out</source_key><sink_key>snr_level_in</sink_key></connection>
<connection><source_block_id>snr_mpsk_receiver_snr_est_cc_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
